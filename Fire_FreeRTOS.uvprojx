# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Fire_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\freertos\include;.\freertos\portable\RVDS\ARM_CM4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./User/: main.c
  group FreeRTOS/Source
    ./freertos/: list.c task.c
    ./freertos/include/: list.h portmacro.h FreeRTOSConfig.h task.h projdefs.h FreeRTOS.h
    ./freertos/portable/RVDS/ARM_CM4/: port.c
  group doc
    ./: readme.txt
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.1
